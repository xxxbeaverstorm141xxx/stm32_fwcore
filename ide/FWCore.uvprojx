# Keil uVision project FWCore.uvprojx, settings and files
target FWCore (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: FWCore +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\app;..\app\zapp;..\mid\freertos\include;..\mid\freertos\cmsis_rtos;..\mid\freertos\portable\inc;..\mid\common\inc;..\mid\delay;..\mid\led;..\mid\lcd1602;..\mid\ntc;..\mid\machine;..\mid\step_motor;..\mid\comm;..\mid\dc_motor;..\mid\btn;..\driver\hal\inc;..\driver\cmsis\stm32f1xx\inc;..\driver\cmsis\inc;..\driver\zen\inc
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../driver/startup/: startup_stm32f103xb.s
  group cmsis
    ../driver/cmsis/stm32f1xx/src/: system_stm32f1xx.c
  group app
    ../app/: main.c
  group zapp
    ../app/zapp/: zapp.c
  group mid/freertos
    ../mid/freertos/: croutine.c event_groups.c freertos.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../mid/freertos/portable/src/: heap_4.c port.c
    ../mid/freertos/cmsis_rtos/: cmsis_os.c
  group mid/common
    ../mid/common/trace/: zerr.c ztrace.c zlog.c
  group mid/led
    ../mid/led/: led.c
  group mid/delay
    ../mid/delay/: delay.c
  group driver/stm32f1xx_hal
    ../driver/hal/src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_timebase_tim.c stm32f1xx_hal_uart.c stm32f1xx_it.c hw.c stm32f1xx_hal_i2c.c stm32f1xx_ll_i2c.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group driver/zen
    ../driver/zen/src/: led_bsp.c zlog_bsp.c delay_bsp.c
software components: CMSIS:CORE 4.3.0
